## src/modules/boat_alloc/Kconfig
```kconfig
menuconfig MODULES_BOAT_ALLOC
    bool "boat_alloc"
    default n
    ---help---
        Custom azimuth-thruster allocation for twin-thruster ship
```
